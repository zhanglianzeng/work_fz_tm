# IAR project Project.ewp, settings and files
configuration SAMC21N18A (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMC21N18A Microchip ATSAMC21N18A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __SAMC21N18A__; F_CPU=48000000
  ICCARM.CCIncludePath2: ./CMSIS; User/driver/qtouch; User/driver/qtouch/include; Device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    CMSIS/: core_cm0plus.h core_cmFunc.h core_cmInstr.h
  group Device
    Device/system/: system_samc21.c
  group Document
    Document/: Readme.md
  group qtouch
    User/driver/qtouch/: driven_shield.c driven_shield.h license.h touch.c touch.h
  group qtouch/include
    User/driver/qtouch/include/: qtm_acq_samc21_0x0020_api.h qtm_binding_layer_0x0005_api.h qtm_common_components_api.h qtm_touch_key_0x0002_api.h touch_api_ptc.h
  group qtouch/lib/iar
    User/driver/qtouch/lib/iar/: qtm_acq_samc21_0x0020.a qtm_binding_layer_cm0p_0x0005.a qtm_touch_key_cm0p_0x0002.a
  group Startup
    Device/startup/: startup_samc21.c
  group User
    User/driver/: adc.c clk.c delay.c driven_dmac.c eic.c eventsystem.c flash.c gpio.c iic_master.c iic_slave.c rtc.c spi.c tc.c tcc.c uart.c wdog.c
    User/middle/adc/: adc_if.c
    User/application/diagnostic/: app_diagnostic_manage.c
    User/application/eeprom/: app_eeprom.c eep_data.c
    User/application/iic/: app_i2c_dimming.c app_iic_comm.c
    User/application/etm/: app_i2c_etm.c
    User/application/led/: app_led_ctrl.c
    User/application/power/: app_power_manage.c
    User/application/soak/: app_soak_manage.c
    User/application/thermal/: app_thermal_manage.c
    User/bsp/: bsp_if.c
    User/common/: buffer.c crc.c
    User/middle/clock/: clk_if.c
    User/: config.h main.c
    User/middle/deserializer/: deserializer_if.c
    User/middle/filter/: filter_if.c
    User/middle/flash/: flash_if.c
    User/middle/lcd/: lcd_if.c
    User/middle/led/: led_if.c
    User/application/life/: life.c
    User/middle/post/: post_if.c
    User/middle/power/: power_if.c
    User/application/scheduler/: scheduler.c
    User/middle/sleep/: sleep_if.c
    User/middle/sys/: sys_if.c
    User/middle/timer/: timer_if.c
    User/middle/touch/: touch_example.c
    User/middle/wdog/: wdog_if.c
